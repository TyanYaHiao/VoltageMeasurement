# IAR project MeasureBoard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MeasureBoard.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: main.c
  group interfaces
    code/interfaces/: adc.c adc.h spi.c spi.h tim.c tim.h uart.c uart.h
  group stm
    code/stm/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40xx.s stm32f4xx.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h system_stm32f4xx.c system_stm32f4xx.h
